# Keil uVision project PT1003.uvprojx, settings and files
target PT1003 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PT1003
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\PT1003.sct
  group Platform
    ./Platform/: startup_stm32f429xx.s system.c platform.h TIMER.c LCD.c SDRAM.c GPIO.c RENDER.c FONT.c DMA2D.c
  group Application
    ./Application/: main.c
  group Texture
    ./Texture/: Texture.c
software components: CMSIS:CORE 4.1.0
